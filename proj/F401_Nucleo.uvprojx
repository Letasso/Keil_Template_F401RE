# Keil uVision project F401_Nucleo.uvprojx, settings and files
target Nucleo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F401_Nucleo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER
  c include: ..\externals\CMSIS\inc;..\externals\CMSIS;..\externals\CMSIS\src;..\externals\RCC\src;..\externals\FRAMEWORK\src;..\externals\GPIO\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application Software
    ../src/: main.c
  group CMSIS
    ../externals/CMSIS/: startup_stm32f401xx.s
    ../externals/CMSIS/src/: system_stm32f4xx.c
    ../externals/CMSIS/inc/: stm32f4xx_conf.h
  group Device_STM32F10x_StdLib
    ../externals/FRAMEWORK/src/: misc.c
    ../externals/RCC/src/: stm32f4xx_rcc.c
    ../externals/GPIO/src/: stm32f4xx_gpio.c
